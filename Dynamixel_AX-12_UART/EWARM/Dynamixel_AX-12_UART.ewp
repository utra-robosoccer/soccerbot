# IAR project Dynamixel_AX-12_UART.ewp, settings and files
configuration Dynamixel_AX-12_UART (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Dynamixel_AX-12_UART.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f4xx.c
  group Application
    ./: 
  group Application/EWARM
    ./:  startup_stm32f446xx.s
  group Application/User
    ./: 
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
